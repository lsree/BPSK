options:
  parameters:
    generate_options: qt_gui
    id: ZMQ_Source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2000'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    timeout: '100'
  states: {state: disabled}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.01:50124
    timeout: '5000'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_req_msg_source_1
  id: zeromq_req_msg_source
  parameters:
    address: tcp://127.0.01:50123
    timeout: '5000'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, zeromq_push_msg_sink_1, in]
- [zeromq_req_msg_source_1, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.7.0

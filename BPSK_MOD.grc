options:
  parameters:
    generate_options: hb_qt_gui
    id: bpsk_mod
    output_language: python
    title: BPSK Modulate
  states: {}

blocks:
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: tx_bytes
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: '"tx_pkt_len"'
    type: complex
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, symbol_dict=[-1+0j, 1+0j]):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PSK Mod',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.symbol_dict = symbol_dict #np.array(symbol_map)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for i,bit in enumerate(input_items[0]):
                  output_items[0][i] = self.symbol_dict[bit]
              return len(output_items[0])
    symbol_dict: '{0:-1+0j, 1:1+0j, 0xFF:0}'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      This python block creates a PMT that contains a packet. The packet follows the following format:

      1. Preamble: Alternating 0s and 1s. The length of the preamble is determined by the Preamble_Len parameter
      2. Syncword: The bit string that the correlator is supposed to detect
      3. Len: A 1 byte field that describes the length of the payload
      4. Payload: The payload/message to be transmitted
      5. Pad: Amount to pad the message. This is to prevent the RRC from truncating the message. Pad value will be 0xFF. The modulator can decide how to handle this.

      | Preamble | Sync Word | Len | Payload | Pad |

      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import queue


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble_len=12, syncword="1110010", pad=127):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Packetize',   # will show up in GRC
                  in_sig= None,
                  out_sig= None
              )
              
              #Store Variables
              self.preamble = np.array(int((preamble_len+1)/2)*[1,0], dtype=np.uint8)[:preamble_len]
              self.syncword = np.array(list(syncword), dtype=np.uint8)
              self.pad_amount = int(pad)
              
              #Make values are binary
              if np.any(self.syncword > 1):
              	print(np.any(self.syncword > 1))
              	raise ValueError("Inavlid Syncword")
              
              # Register port and handler
              self.message_port_register_in(pmt.intern('MSG_In'))
              self.message_port_register_out(pmt.intern('Unpacked Packet'))
              self.set_msg_handler(pmt.intern('MSG_In'), self.handle_msg)
              
              
          def handle_msg(self, msg):
              #Get msg
              payload = pmt.to_python(msg)
              
              payload = np.fromstring(payload[1], dtype=np.uint8)
              payload_len = np.array([len(payload)], dtype=np.uint8)
              
              packet = np.concatenate((self.preamble, self.syncword, np.unpackbits(np.concatenate((payload_len, payload)), bitorder='big'), np.full(self.pad_amount, 0xFF)))
              

           
              #Create PMT u8vector
              pmt_out = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet), packet))
              self.message_port_pub(pmt.intern('Unpacked Packet'), pmt_out)
    pad: (rrc_ntaps+1)/2
    preamble_len: '56'
    syncword: '"1110010"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from PyQt5 import Qt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import qtgui
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"tx_pkt_len"'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.51'
    gain: '.5'
    interp: sps
    ntaps: rrc_ntaps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: rrc_ntaps
  id: parameter
  parameters:
    label: 'RRC # of Taps'
    value: 2**7-1
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: TX Sample Rate
    type: intx
    value: int(250e3)
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples Per Symbol
    type: intx
    value: '10'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}

connections:
- [blocks_tagged_stream_multiply_length_0, '0', pad_sink_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_sink_x_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1, '0', root_raised_cosine_filter_0, '0']
- [epy_block_2, Unpacked Packet, pdu_pdu_to_tagged_stream_0, pdus]
- [pad_source_0, out, epy_block_2, MSG_In]
- [pdu_pdu_to_tagged_stream_0, '0', virtual_sink_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_file_sink_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [virtual_source_0, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

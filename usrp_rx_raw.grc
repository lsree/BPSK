options:
  parameters:
    generate_options: qt_gui
    id: USRP_RX_Raw
    output_language: python
    title: USRP_RX_Raw
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    label: Carrier Frequency
    start: 905e6
    step: 1e4
    stop: 930e6
    value: 915e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '89'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 38.4e3*2
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rf/Documents/BPSK/rx_raw.iq
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 1/samp_rate
    center_freq0: carrier_freq
    dev_addr: '"serial=30F5982"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

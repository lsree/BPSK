options:
  parameters:
    generate_options: qt_gui
    id: BPSK_FullSystem
    output_language: python
    title: BPSK Transmit
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0
    label: Baseband gain
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '8'
  states: {}
- name: bpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: cos_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3
    label: cos freq
    min_len: '100'
    start: 100e3
    step: 1e3
    stop: 700e3
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1
    label: Frequency
    start: 85e6
    step: 1e5
    stop: 110e6
    value: 89.7e6
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,3
    label: Frequency
    min_len: '50'
    start: 900e6
    step: 1e5
    stop: 950e6
    value: 915e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2
    label: LNA Gain
    min_len: '47'
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '36'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1
    label: RF Gain
    min_len: '2'
    start: '0'
    step: '11'
    stop: '11'
    value: '0'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: tx_en
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Transmit Enable
    min_len: '5'
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
    widget: slider
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2
    label: tx gain
    min_len: '2'
    rangeType: int
    start: '0'
    step: '11'
    stop: '11'
    value: '0'
    widget: counter
  states: {}
- name: tx_lna
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: TX LNA
    min_len: '47'
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '32'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '30'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cos_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: tx_en
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ubuntu/Documents/lsreeharikesan/senior_rf_exercises-master/4.00_Communication-Systems-Theory-and-Application/4.06_Demonstrate-Digital-Modulation/BPSK/BPSK_RX
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ubuntu/Documents/lsreeharikesan/senior_rf_exercises-master/4.00_Communication-Systems-Theory-and-Application/4.06_Demonstrate-Digital-Modulation/BPSK/tx_bytes
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.4'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk_constellation
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: '.5'
    samps_per_sym: sps
    type: cc
    w: 2*np.pi/sps/100
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble=[0xAA,0xAA], syncword=[0x56]):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Packet Formatter',   # will show up in GRC
                  in_sig= None,
                  out_sig= None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'),self.handle_msg)
              
              self.preamble = np.array(preamble,dtype=np.uint8)
              self.syncword = np.array(syncword,dtype=np.uint8)

          def handle_msg(self, msg):
              #Get msg
              payload = pmt.to_python(msg)
              
              #print(f"Payload: {payload}\n Payload type: {type(payload)}")
              
              payload = np.fromstring(payload[1], dtype=np.uint8)
              #print(f"Payload: {payload}")
              #Get Payload length
              payload_len = len(payload)
              #print(f"Payload Len: {payload_len}")
              payload_len = np.array([len(payload) >> 8, len(payload) & 0xFF], dtype=np.uint8)
              #print(f"Payload Len: {payload_len}")
              
              packet = np.concatenate([self.preamble, self.syncword, payload_len, payload_len, 	
              	payload])
              
              #print(f"Packet: {packet}")
              #Create PMT u8vector
              pmt_out = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet), packet))
              self.message_port_pub(pmt.intern('PDU_out'), pmt_out)
    preamble: '[0x55, 0x55, 0x55, 0x55, 0x55]'
    syncword: '[90,232]'
  states: {state: disabled}
- name: freq_offset
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,4
    name: '"Freq Offset"'
    type: float
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=1"'
    bb_gain0: '0'
    bw0: samp_rate
    freq0: tx_freq
    gain0: tx_gain
    if_gain0: tx_lna
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: bb_gain
    bw0: samp_rate
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '1024'
    early_behavior: pdu.EARLY_BURST_BALK
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,2
    name: '"TX Output - IQ"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3,3
    name: '"TX Output - IQ"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,2
    name: '"Pocessed - IQ"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: Payload
    label: Payload
    type: string
    value: '"Hello World!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!AAAAAAAAAAAAAAAAAAAAA"'
  states: {state: disabled}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: 4,3
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    label1: '"RRC Output Freq Domain"'
    name: '"TX Output - Freq"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 3,1
    label1: '"RRC Output Freq Domain"'
    name: '"RX - Freq"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 4,0
    label1: '"RRC Output Freq Domain"'
    name: '"Processed - Freq"'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1
    name: '"TX Output - Time"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,2
    name: '"RX- Time"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1
    name: '"Processed- Time"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0
    name: '"RX Waterfall"'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: sps
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: pdus
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_display
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: process_display
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: pdus
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_display
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: process_display
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_random_source_x_0, '0', blocks_copy_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0, '0']
- [blocks_copy_0, '0', digital_constellation_modulator_0, '0']
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_2, PDU_in]
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_fll_band_edge_cc_0, '1', freq_offset, '0']
- [epy_block_2, PDU_out, virtual_sink_0, '0']
- [osmosdr_source_0_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0_0, '0', virtual_sink_1, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_null_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_0, set_msg]
- [root_raised_cosine_filter_0, '0', virtual_sink_1_0, '0']
- [virtual_source_0, '0', pdu_pdu_to_stream_x_0, pdus]
- [virtual_source_1, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_1, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [virtual_source_1_0, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [virtual_source_1_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

options:
  parameters:
    generate_options: qt_gui
    id: bpsk_transmit_receive
    output_language: python
    title: BPSK RX/TX
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 905e6
    step: 1e5
    stop: 930e6
    value: 915e6
  states: {}
- name: device_addr
  id: variable
  parameters:
    value: '"serial=30F5982"'
  states: {state: disabled}
- name: device_addr
  id: variable
  parameters:
    value: '"serial=30BC4A2"'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '89.6'
    value: '35'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: rx_sps
  id: variable
  parameters:
    value: 10*2
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: int(500e3/2)
  states: {}
- name: tx_sps
  id: variable
  parameters:
    value: 10*2
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '3000'
  states: {}
- name: bpsk_demod_0
  id: bpsk_demod
  parameters:
    rx_samp_rate: rx_samp_rate
    rx_sps: rx_sps
    squelch_power: '-55'
  states: {}
- name: bpsk_mod_0
  id: bpsk_mod
  parameters:
    rrc_ntaps: 2**7-1
    samp_rate: tx_samp_rate
    sps: tx_sps
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: Payload
    label: Payload
    type: string
    value: '"abcdefghijklmnopqrstuvwxyzABCDEFGHIJKLMNOPQRSTUVWXYZ"'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    dev_addr: device_addr
    gain0: tx_gain
    len_tag_name: tx_pkt_len
    samp_rate: tx_samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    dev_addr: device_addr
    gain0: rx_gain
    samp_rate: rx_samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, bpsk_mod_0, in]
- [bpsk_demod_0, out, blocks_message_debug_0, print]
- [bpsk_mod_0, '0', uhd_usrp_sink_0_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_0, set_msg]
- [uhd_usrp_source_0, '0', bpsk_demod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

options:
  parameters:
    generate_options: qt_gui
    id: usrp_rx
    output_language: python
    title: USRP RX
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 905e6
    step: 1e5
    stop: 930e6
    value: 915e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '89.6'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: squelch_power
  id: variable_qtgui_range
  parameters:
    label: Squelch Power
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '-65'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rf/Documents/BPSK/usrp_rx_shift_LPF_custom_squelch.iq
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      This block tags bursts greater than the threshold and squelches samples outside of that burst to zero. It does this by using an Exponentially Weighted Moving Average Filter (EWMA). This is a type of single pole IIR filter. Samples are tagged True if the block believes a burst is occurring. 

      Threshold_db    Cutoff Threshold in dB
      Cutoff_Freq     Cutoff frequency normalized to sample rate
      Burst_Tag_Name  Name of tag that gets marked true if burst is occurring
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import filter
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold_db=-65, cutoff_freq=.01, burst_tag_name = "rx_burst"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Burst Detect & Squelch',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = 10**(threshold_db/10)
              self.alpha = cutoff_freq/(1+cutoff_freq)
              self.prev_filt = 0  #Save previous value of the filter
              self.tag_key = pmt.intern(burst_tag_name)


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              input_samp = input_items[0]
              mag2 = input_samp * np.conj(input_samp)
              
              output = np.zeros(len(input_samp), dtype=complex) #Squelched by default
              # Apply Filter
              for i in range(0, len(mag2)):
                  self.prev_filt = self.alpha*mag2[i] + (1-self.alpha)*self.prev_filt 
                  
                  if (self.prev_filt >= self.threshold):
                      self.add_item_tag(0, self.nitems_written(0) + i, self.tag_key, 
                          pmt.PMT_T)
                      output[i] = input_samp[i]

                      
              output_items[0][:] = output
              return len(output_items[0])
    burst_tag_name: '"packet_len"'
    cutoff_freq: 1/(sps*4)
    threshold_db: squelch_power
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from scipy import signal, fft
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, nfft=1024, order=2):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Coarse Frequency Correction',   # will show up in GRC
                  in_sig=[(np.complex64, nfft)],
                  out_sig=[(np.complex64, nfft)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.nfft = nfft
              self.set_output_multiple(nfft)
              self.order = order
              self.fft_freqs = fft.fftfreq(nfft)

              
          #def general_work(self, input_items, output_items):
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              samples = input_items[0]
              print(f"Len samples: {input_items[0].shape}")
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))
              if(tagTuple):
                  print(f"tagTuple Len {len(tagTuple)}, Num items {len(input_items[0])}")
              #Get Tags

             
              

              freq_magnitudes = fft.fft(samples**self.order, self.nfft)
              print(f"Argmax: {np.argmax(np.abs(freq_magnitudes))}")
              freq_offset = self.fft_freqs[np.argmax(np.abs(freq_magnitudes))]/self.order
              print(f"Freq offset: {freq_offset}")
                  
                  
                  
              #output_items[0][:] = samples[:self.nfft]*np.exp(2j*(np.pi*freq_offset*np.arange(0,self.nfft)))
                  #self.produce(0, self.nfft)
                  #self.consume(0, self.nfft)
              #else:
                  #self.consume(0,0)
                  #self.produce(0,0)
              output_items = input_items
              
              
              return len(output_items[0])
    nfft: '1024'
    order: '2'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    type: ccc
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: RC
    name: '"Freq RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: 1024*5
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: RRC
    name: '"Waterfall RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Squelched"'
    type: complex
    update_time: '0.1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    dev_addr: '"serial=31909E8"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_1, '0']
- [blocks_tagged_stream_align_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_tagged_stream_align_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [epy_block_1, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

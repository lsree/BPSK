options:
  parameters:
    generate_options: qt_gui
    id: usrp_rx
    output_language: python
    title: USRP RX
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 905e6
    step: 1e5
    stop: 930e6
    value: 915e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '89.6'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: squelch_power
  id: variable_qtgui_range
  parameters:
    label: Squelch Power
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '-65'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rf/Documents/BPSK/usrp_rx_shift_LPF_custom_squelch.iq
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import filter
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold_db=-65, cutoff_freq=.01, burst_tag_name = "rx_burst"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Burst Detect & Squelch',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = 10**(threshold_db/10)
              self.alpha = cutoff_freq/(1+cutoff_freq)
              self.prev_filt = 0  #Save previous value of the filter
              self.tag_key = pmt.intern(burst_tag_name)


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              input_samp = input_items[0]
              mag2 = input_samp * np.conj(input_samp)
              
              output = np.zeros(len(input_samp), dtype=complex) #Squelched by default
              # Apply Filter
              for i in range(0, len(mag2)):
                  self.prev_filt = self.alpha*mag2[i] + (1-self.alpha)*self.prev_filt 
                  
                  if (self.prev_filt >= self.threshold):
                      self.add_item_tag(0, self.nitems_written(0) + i, self.tag_key, 
                          pmt.PMT_T)
                      output[i] = input_samp[i]

                      
              output_items[0][:] = output
              return len(output_items[0])
    burst_tag_name: '"packet_len"'
    cutoff_freq: 1/(sps*4)
    threshold_db: squelch_power
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: RC
    name: '"Freq RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: 1024*5
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: RRC
    name: '"Waterfall RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Squelched"'
    type: complex
    update_time: '0.1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    dev_addr: '"serial=30BC4A2"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_tagged_stream_align_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '0', blocks_tagged_stream_align_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

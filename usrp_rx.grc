options:
  parameters:
    generate_options: qt_gui
    id: usrp_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 905e6
    step: 1e5
    stop: 930e6
    value: 915e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '89.6'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: squelch_power
  id: variable_qtgui_range
  parameters:
    label: Squelch Power
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '-65'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.0141041'
    threshold: squelch_power
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: tx_eob
    false_value: 'False'
    true_key: tx_sob
    true_value: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rf/Documents/BPSK/usrp_rx_shift_LPF_squelch.iq
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rf/Documents/BPSK/usrp_rx_raw.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: sym_rate
    sample_rate: samp_rate
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: sym_rate/64
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: sym_rate/64
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: sym_rate*1.2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: sym_rate*.1
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: RC
    name: '"Freq RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Signal Real
    label2: SIgnal Imag
    label3: Trigger
    name: '"Burst Tagged"'
    nconnections: '2'
    size: 1024*10
    srate: samp_rate
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: tx_sob
    type: complex
    ymax: '.005'
    ymin: '-.005'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: magenta
    ctrlpanel: 'True'
    label1: LPF
    label2: Short
    name: '"Trigger"'
    nconnections: '2'
    size: 1024*10
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: RRC
    label2: Raw
    name: '"Waterfall RC"'
    nconnections: '2'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Squelched"'
    type: complex
    update_time: '0.1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: sym_rate*2.5
    center_freq0: carrier_freq+sym_rate
    dev_addr: '"serial=30BC4A2"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_simple_squelch_cc_0, '0', blocks_burst_tagger_0, '0']
- [analog_simple_squelch_cc_0, '0', blocks_file_sink_0, '0']
- [analog_simple_squelch_cc_0, '0', low_pass_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_float_to_short_0, '0', blocks_short_to_float_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_1, '0']
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_0, '1']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_throttle2_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_1, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

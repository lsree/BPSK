options:
  parameters:
    generate_options: qt_gui
    id: usrp_rx
    output_language: python
    title: USRP RX
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 905e6
    step: 1e5
    stop: 930e6
    value: 915e6
  states: {}
- name: coarse_freq_fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '89.6'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: squelch_power
  id: variable_qtgui_range
  parameters:
    label: Squelch Power
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '-60'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rf/Documents/BPSK/usrp_rx_shift_LPF_custom_squelch.iq
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: coarse_freq_fft_size
    type: complex
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: coarse_freq_fft_size
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      This block tags bursts greater than the threshold and squelches samples outside of that burst to zero. It does this by using an Exponentially Weighted Moving Average Filter (EWMA). This is a type of single pole IIR filter. Samples are tagged True if the block believes a burst is occurring. 

      Threshold_db    Cutoff Threshold in dB
      Cutoff_Freq     Cutoff frequency normalized to sample rate
      Burst_Tag_Name  Name of tag that gets marked true if burst is occurring
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import filter
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold_db=-65, cutoff_freq=.01, burst_tag_name = "rx_burst"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Burst Detect & Squelch',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = 10**(threshold_db/10)
              self.alpha = cutoff_freq/(1+cutoff_freq)
              self.prev_filt = 0  #Save previous value of the filter
              self.tag_key = pmt.intern(burst_tag_name)


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              input_samp = input_items[0]
              mag2 = input_samp * np.conj(input_samp)
              
              output = np.zeros(len(input_samp), dtype=complex) #Squelched by default
              # Apply Filter
              for i in range(0, len(mag2)):
                  self.prev_filt = self.alpha*mag2[i] + (1-self.alpha)*self.prev_filt 
                  
                  if (self.prev_filt >= self.threshold):
                      self.add_item_tag(0, self.nitems_written(0) + i, self.tag_key, 
                          pmt.PMT_T)
                      output[i] = input_samp[i]

                      
              output_items[0][:] = output
              return len(output_items[0])
    burst_tag_name: '"packet_len"'
    cutoff_freq: 1/(sps*4)
    threshold_db: squelch_power
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      This block assumes that the bursty data is aligned (Tagged stream aligned using 

              #TODO Need to handle transition between fft chunks either
              # 1. Id burst and fft the whole burst. Need to reset between bursts
              # 2. Id burst and fft first part of burst and then maintain that correction for the whole burst
              # 3. Implement a smoothing function


                  #for tag in tagTuple:
                  #print(f"tagTuple Offset {tag.offset} Key {pmt.to_python(tagTuple[0].key)}")
                  #print(f"Len input: {input_items[0].shape}")
                  #print(f"ninput items: {self.nitems_read(0)} Relative Offset: {tag.offset - self.nitems_read(0)}")
      """

      import numpy as np
      from scipy import signal, fft
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, nfft=2048, order=2, burst_tag_name = "rx_burst"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Coarse Frequency Correction',   # will show up in GRC
                  in_sig=[(np.complex64, nfft)],
                  out_sig=[(np.complex64, nfft)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.nfft = nfft
              #self.set_output_multiple(nfft)
              self.order = order
              self.fft_freqs = fft.fftfreq(nfft)
              self.time_vector = np.arange(0, nfft)/nfft
              self.tag_key = pmt.intern(burst_tag_name)

              
          #def general_work(self, input_items, output_items):
          def work(self, input_items, output_items):
              input_vectors = input_items[0]
              
              #Check if correct tag is present
              tagTuple = self.get_tags_in_window(0, 0, len(input_vectors), self.tag_key)
              if(tagTuple):   #I'm not going to check each tag for it's location because that would be computationally intensive     
                  #Intead we'll just FFT each group of inputs vectors that have a burst tag present somewhere in them. 
                  for i in range(0, len(input_vectors)):
                      samples = input_vectors[i]

                      freq_magnitudes = np.abs(fft.fft(samples**self.order, self.nfft))
                      freq_offset = self.fft_freqs[np.argmax(freq_magnitudes)]/self.order
                      output_items[0][i] = samples*np.exp(2j*np.pi*freq_offset*self.time_vector)
              else:
                  output_items[0][:] = 0
              
              return len(output_items[0])
    burst_tag_name: '''packet_len'''
    nfft: coarse_freq_fft_size
    order: '2'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    type: ccc
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: RC
    name: '"Freq RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: 1024*5
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: RRC
    name: '"Waterfall RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Squelched"'
    type: complex
    update_time: '0.1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: carrier_freq
    dev_addr: '"serial=30BC4A2"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_1, '0']
- [blocks_tagged_stream_align_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_tagged_stream_align_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [epy_block_1, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

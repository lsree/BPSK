options:
  parameters:
    generate_options: qt_gui
    id: usrp_rx
    output_language: python
    title: USRP RX
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: 905e6
    step: 1e5
    stop: 930e6
    value: 915e6
  states: {}
- name: coarse_freq_fft_size
  id: variable
  parameters:
    value: 2**13+4096
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '89.6'
    value: '35'
  states: {}
- name: rx_device_addr
  id: variable
  parameters:
    value: '"serial=31909E8"'
  states: {state: disabled}
- name: rx_device_addr
  id: variable
  parameters:
    value: '"serial=30F5982"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: 10*2
  states: {}
- name: squelch_power
  id: variable_qtgui_range
  parameters:
    label: Squelch Power
    rangeType: int
    start: '-100'
    step: '1'
    stop: '100'
    value: '-55'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx_raw_pll
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: rx_raw_TED
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: rx_raw_rrc
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: rx_raw
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: coarse_freq_fft_size
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: coarse_freq_fft_size
    type: complex
  states: {state: disabled}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters: {}
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      This block tags bursts greater than the threshold and squelches samples outside of that burst to zero. It does this by using an Exponentially Weighted Moving Average Filter (EWMA). This is a type of single pole IIR filter. Samples are tagged True if the block believes a burst is occurring. 

      Threshold_db    Cutoff Threshold in dB
      Cutoff_Freq     Cutoff frequency normalized to sample rate
      Burst_Tag_Name  Name of tag that gets marked true if burst is occurring
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import filter
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold_db=-65, cutoff_freq=.01, burst_tag_name = "rx_burst"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Burst Detect & Squelch',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = 10**(threshold_db/10)
              self.alpha = cutoff_freq/(1+cutoff_freq)
              self.prev_filt = 0  #Save previous value of the filter
              self.tag_key = pmt.intern(burst_tag_name)
              self.message_port_register_out(pmt.intern('Packet'))


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              input_samp = input_items[0]
              mag2 = input_samp * np.conj(input_samp)
              
              output = np.zeros(len(input_samp), dtype=complex) #Squelched by default
              # Apply Filter
              for i in range(0, len(mag2)):
                  self.prev_filt = self.alpha*mag2[i] + (1-self.alpha)*self.prev_filt 
                  
                  if (self.prev_filt >= self.threshold):
                      self.add_item_tag(0, self.nitems_written(0) + i, self.tag_key, 
                          pmt.PMT_T)
                      output[i] = input_samp[i]

                      
              output_items[0][:] = output
              return len(output_items[0])
    burst_tag_name: '"packet_len"'
    cutoff_freq: 1/(4*sps)
    threshold_db: squelch_power
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      This block assumes that the bursty data is aligned (Tagged stream aligned using 

              #TODO Need to handle transition between fft chunks either
              # 1. Id burst and fft the whole burst. Need to reset between bursts
              # 2. Id burst and fft first part of burst and then maintain that correction for the whole burst
              # 3. Implement a smoothing function


                  #for tag in tagTuple:
                  #print(f"tagTuple Offset {tag.offset} Key {pmt.to_python(tagTuple[0].key)}")
                  #print(f"Len input: {input_items[0].shape}")
                  #print(f"ninput items: {self.nitems_read(0)} Relative Offset: {tag.offset - self.nitems_read(0)}")
      """

      import numpy as np
      from scipy import signal, fft
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, nfft=2**13+4096, order=2, burst_tag_name = "rx_burst"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Coarse Frequency Correction',   # will show up in GRC
                  in_sig=[(np.complex64, nfft)],
                  out_sig=[(np.complex64, nfft)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.nfft = nfft
              #self.set_output_multiple(nfft)
              self.order = order
              self.fft_freqs = fft.fftfreq(nfft)
              self.time_vector = np.arange(0, nfft)/nfft
              self.tag_key = pmt.intern(burst_tag_name)

              
          #def general_work(self, input_items, output_items):
          def work(self, input_items, output_items):
              input_vectors = input_items[0]
              
              #Check if correct tag is present
              tagTuple = self.get_tags_in_window(0, 0, len(input_vectors), self.tag_key)
              if(tagTuple):   #I'm not going to check each tag for it's location because that would be computationally intensive     
                  #Intead we'll just FFT each group of inputs vectors that have a burst tag present somewhere in them. 
                  for i in range(0, len(input_vectors)):
                      samples = input_vectors[i]

                      freq_magnitudes = np.abs(fft.fft(samples**self.order, self.nfft))
                      freq_offset = self.fft_freqs[np.argmax(freq_magnitudes)]/self.order
                      output_items[0][i] = samples*np.exp(2j*np.pi*freq_offset*self.time_vector)
              else:
                  output_items[0][:] = 0
              
              return len(output_items[0])
    burst_tag_name: '''packet_len'''
    nfft: coarse_freq_fft_size
    order: '2'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom scipy import signal, fft\nimport pmt\n\n\nclass blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def gardner_TED(self, signal, sample_pos, sps):\n        error = signal[sample_pos-int(sps/2)] * (signal[sample_pos] - signal[sample_pos-sps])\n        return error.real + error.imag\n    \n    def early_late_TED(self,signal, sample_pos, sps): \n        error = signal[sample_pos] * (signal[sample_pos+int(sps/2)] - signal[sample_pos-int(sps/2)])\n        return error.real + error.imag\n        \n    def __init__(self, interpolation_factor=1, sps=2, timing_error_detector=\"gardner\", damping_factor=1, bandwidth=.2, burst_tag_name='rx_burst'):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.decim_block.__init__(\n            self,\n            name='Timing Error Detector',   \n            in_sig=[np.complex64],\n            out_sig=[np.complex64], \n            decim = sps\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.tag_key = pmt.intern(burst_tag_name)\n        self.set_relative_rate(1.0/sps)\n        self.interpolation_factor = interpolation_factor\n        self.sps = sps\n        self.interp_sps = sps*interpolation_factor\n        self.pll_i = self.interp_sps\n        \n        #Calculate Ki & Kp\n        theta = bandwidth/ (2 * (damping_factor + 1/(4*damping_factor)))\n        delta = 1+2*damping_factor*theta + theta**2\n        self.kp = 4*damping_factor*theta/(delta*2)\n        self.ki = 4*theta**2/(delta*2)\n        \n        self.error_integral = 0\n        TED = {'gardner':self.gardner_TED, 'early_late':self.early_late_TED}\n        self.timing_error_detector = TED[timing_error_detector]\n        \n        \n        #if timing_error_detector == \"gardner\":\n        #    self.timing_error_detector = self.gardner_TED\n        #elif timing_error_detector == \"early_late\":\n        #    self.timing_error_detector = self.early_late_TED\n        #else:\n        #    raise ValueError(\"Invalid Timing Error Detector\")\n            \n\n    def work(self, input_items, output_items):\n        #TODO Check if in Burst to reduce compute. I just check if chunk has bust tagged data, but I should get the first one and then start there\n        tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]), self.tag_key)\n        if(tagTuple):\n            #print(f\"Tag Tuple Len: {len(tagTuple)}\")\n            #Interpolate\n            interp_signal = signal.resample_poly(input_items[0], self.interpolation_factor, 1)\n            #Implement PLL\n            pll_start = self.pll_i\n            while self.pll_i < len(interp_signal) - self.interp_sps:\n                error = self.timing_error_detector(interp_signal, self.pll_i, self.interp_sps)\n                self.error_integral += self.ki*error\n                pll_output = self.kp*error + self.error_integral\n                self.pll_i += int(self.interp_sps + np.rint(pll_output*self.interp_sps))\n\n                output_items[0][int(self.pll_i/self.interp_sps)] = interp_signal[self.pll_i]\n            #print(f\"Samples Iterated Thru: {self.pll_i - pll_start}\")\n            #Wrap self.pll_i for the next chunk of data\n            self.pll_i = self.pll_i % self.interp_sps + self.interp_sps\n        else:\n            output_items[0][:] = 0\n\n        return len(output_items[0])\n        \n\n"
    bandwidth: '0.001688'
    burst_tag_name: '''packet_len'''
    damping_factor: '1'
    interpolation_factor: 2**5
    sps: sps
    timing_error_detector: '''early_late'''
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, damping_factor=1.0, loop_bandwidth = .002, burst_tag_name='rx_burst'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BSPK PLL',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tag_key = pmt.intern(burst_tag_name)
              
              #Calculate Ki & Kp
              theta = loop_bandwidth/ (2 * (damping_factor + 1/(4*damping_factor)))
              delta = 1+2*damping_factor*theta + theta**2
              self.kp = 4*damping_factor*theta/(delta*2)
              self.ki = 4*theta**2/(delta*2)
              self.error_integral = 0
              self.phase_estimate = 0

          def work(self, input_items, output_items):
               #TODO Check if in Burst to reduce compute. I just check if chunk has bust tagged data, but I should get the first one and then start there
              #tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]), self.tag_key)
              output_items[0][:] = 0
              #if(tagTuple):
                  #first_valid_sample = tagTuple[0].offset - self.nitems_read(0)#I am assuming that the first tag is the first burst signal
                  #Do PLL through chunk
                  #print(f"1st Valid Sample {first_valid_sample} Value: {pmt.to_python(tagTuple[0].value)}")
                  #for i, sample in enumerate(input_items[0][first_valid_sample:]):
              for i, sample in enumerate(input_items[0]):
                  if sample.real != 0:
                      output_items[0][i] = sample*np.exp(-1j*self.phase_estimate)
                      error = output_items[0][i].imag/output_items[0][i].real
                      self.error_integral += self.ki*error
                      self.phase_estimate += self.kp*error + self.error_integral
                      self.phase_estimate = np.fmod(self.phase_estimate, 2*np.pi)    #Prevent pll_phase from getting too big
              #print(output_items[0][first_valid_sample+1])
              #print(f"Phase estimate: {self.phase_estimate}")

              return len(output_items[0])
    burst_tag_name: '''packet_len'''
    damping_factor: '1.2'
    loop_bandwidth: '.2'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BPSK Demod',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #print((input_items[0]>1)*1)
              output_items[0][:] = (input_items[0].real>0)*1
              return len(output_items[0])
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      tag_name Locates where the packet starts and it's value stores if it needs to be inverted
          False: Does not need to be inverted
          True: Needs to be inverted
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, syncword="10101110010", tag_name="pkt_start_invert"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Correlate Syncword',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.len_mask = 2**len(syncword)-1  #This is to prevent the correlator from comparing numbers greater than the syncword
              self.syncword = int(syncword,2)
              self.syncword_inv = self.syncword ^ self.len_mask
           
              self.packed_bits = 0
              self.tag_name = pmt.intern(tag_name)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for i, bit in enumerate(input_items[0]):
                  #print(f"In loop {i}")
                  #Shift new bit in
                  self.packed_bits = (self.packed_bits << 1) | (bit & 1)
                  self.packed_bits &= self.len_mask

                  #Check correlation
                  #Normal/Non-inverted
                  correlated = self.packed_bits ^ self.syncword
                  if correlated.bit_count() == 0:
                      #Add Tag
                      self.add_item_tag(0, self.nitems_written(0) + i + 1, self.tag_name, pmt.PMT_F)
                      
                  #Check Inverted
                  correlated_inv = self.packed_bits ^ self.syncword_inv
                  if correlated_inv.bit_count() == 0:
                      #Add Tag
                      self.add_item_tag(0, self.nitems_written(0) + i + 1, self.tag_name, pmt.PMT_T)
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    syncword: '"10101110010"'
    tag_name: '"pkt_start_invert"'
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, tag_name="pkt_start"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Parse Header',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.state = "Scanning"
              self.len_bit_stream = np.empty(0, dtype=np.uint8)
              self.tag_name = pmt.intern(tag_name)
              self.invert = False
              
              self.msg_len = 0
              self.msg_len_bitstream = np.empty(0, dtype=np.uint8)
              
              self.msg_bitstream = np.empty(0, dtype=np.uint8)
              self.message_port_register_out(pmt.intern('Packet'))
              

          def work(self, input_items, output_items):
             
              i = 0
              while i < len(input_items[0]):
                  if self.state == "Scanning":
                      i = self.scanning(input_items[0], i)
                  elif self.state == "Get Len":
                      i = self.get_len(input_items[0], i)
                  elif self.state == "Get MSG":
                      i = self.get_msg(input_items[0], i)
                  else:
                      print(f"Unknown state: {self.state}")
                      self.state = "Scanning"
              return len(input_items[0])
              
          def scanning(self, input_items, index):
              ''' This function returns the relative position of the first available tag where the correlator
              '''
              #Get tags
              tags = self.get_tags_in_window(0, index, len(input_items), self.tag_name)
              if tags:
                  self.state = "Get Len"
                  self.invert = pmt.to_python(tags[0].value)
                  return tags[0].offset - self.nitems_read(0) #Return relative offset
              else: #No tag found advance loop to next chunk
                  return len(input_items)
                  
          def get_len(self, input_items, i):
              #Get 8 bits for len
              #Deal with edge case where there's not enough samples to constitute the len field
              if len(input_items[i:]) < 8 - len(self.msg_len_bitstream):
                  self.msg_len_bitstream = np.concatenate([self.msg_bitstream, input_items[i:]])
                  return i + len(input_items)
              
              #There are 8 bits
              self.msg_len_bitstream = np.concatenate([self.msg_len_bitstream, input_items[i:i+8-len(self.msg_len_bitstream)]])
              self.msg_len = np.packbits(self.msg_len_bitstream)[0]
              #Check for inversion
              if self.invert:
                  self.msg_len ^= 0xFF
                  
              #Change state & Reset
              self.msg_len_bitstream = np.empty(0, dtype=np.uint8)
              self.state = "Get MSG"
              
              return i+8
              
          def get_msg(self, input_items, i):
              #Deal w/ edge case where there not enough samples to constitute the entire msg
              if (len(input_items[i:]) < self.msg_len*8 - len(self.msg_bitstream)):
                  self.msg_bitstream = np.concatenate([self.msg_bitstream, input_items[i:]])
                  return i + len(input_items[i:])
                  
              #There are enough samples
              num_bits_read = self.msg_len*8-len(self.msg_bitstream)
              msg = np.concatenate([self.msg_bitstream, input_items[i:i+num_bits_read]])
              msg = np.packbits(msg)
              if self.invert:
                  msg = ~msg
              
              pmt_out = pmt.cons(pmt.intern("MSG"), pmt.to_pmt(msg))
              self.message_port_pub(pmt.intern('Packet'), pmt_out)
              
              #Change state and reset
              self.state = "Scanning"
              msg_len = self.msg_len
              self.msg_len = 0
              self.msg_bitstream = np.empty(0, dtype=np.uint8)
              return i + num_bits_read
    tag_name: '"pkt_start_invert"'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
    xmax: '.01'
    xmin: '-.01'
    ymax: '.01'
    ymin: '-.01'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"BPSK PLL"'
    size: '1024'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"packet_len"'
    type: complex
    xmax: '.01'
    xmin: '-.01'
    ymax: '.01'
    ymin: '-.01'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    label1: Before TED Real
    label2: Before TED Imag
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    style1: '4'
    style2: '4'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '.005'
    ymin: '-.005'
    yunit: '"RRC Eye"'
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    label1: After TED Real
    label2: After TED Imag
    samp_per_symbol: '1'
    size: '1024'
    srate: samp_rate
    style1: '4'
    style2: '4'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    ymax: '.01'
    ymin: '-.01'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    label1: RC
    name: '"Freq RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: '"RRC Time"'
    size: sps*300*2
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: '"PLL Time"'
    size: sps*300
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: '"TED Time"'
    size: sps*300
    srate: samp_rate
    tr_chan: '1'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Demoded"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: RRC
    name: '"Waterfall RC"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Squelched"'
    type: complex
    update_time: '0.1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.51'
    decim: '1'
    gain: '1'
    ntaps: 2**7-1
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: carrier_freq
    dev_addr: rx_device_addr
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: cfo_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: cfo_out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_stream_to_vector_0, '0', epy_block_1, '0']
- [blocks_tagged_stream_align_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_tagged_stream_align_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_0, '0']
- [epy_block_0, '0', blocks_tagged_stream_align_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [epy_block_1, '0', blocks_vector_to_stream_0, '0']
- [epy_block_2, '0', blocks_file_sink_0_0, '0']
- [epy_block_2, '0', epy_block_3, '0']
- [epy_block_2, '0', qtgui_const_sink_x_0, '0']
- [epy_block_2, '0', qtgui_eye_sink_x_0_0, '0']
- [epy_block_2, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_3, '0', blocks_file_sink_0, '0']
- [epy_block_3, '0', epy_block_4, '0']
- [epy_block_3, '0', qtgui_const_sink_x_0_0, '0']
- [epy_block_3, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_4, '0', virtual_sink_1, '0']
- [epy_block_5, '0', blocks_char_to_float_0, '0']
- [epy_block_5, '0', blocks_null_sink_0, '0']
- [epy_block_5, '0', epy_block_6, '0']
- [epy_block_6, Packet, blocks_message_debug_0, print]
- [root_raised_cosine_filter_0, '0', blocks_file_sink_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', epy_block_2, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0_0_1, '0']
- [uhd_usrp_source_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', root_raised_cosine_filter_0, '0']
- [virtual_source_1, '0', epy_block_5, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

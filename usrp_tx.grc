options:
  parameters:
    generate_options: qt_gui
    id: USRP_TX
    output_language: python
    title: USRP TX
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    label: Carrier Frequency
    start: 905e6
    step: 1e4
    stop: 930e6
    value: 915e6
  states: {}
- name: cos_freq
  id: variable_qtgui_range
  parameters:
    label: Carrier Frequency
    start: 500e3
    step: 1e4
    stop: 8e6
    value: 1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '76'
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(8e6)
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cos_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble_len=12, syncword="1110010"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Packetize',   # will show up in GRC
                  in_sig= None,
                  out_sig= None
              )
              
              #Store Variables
              self.preamble = np.array(int((preamble_len+1)/2)*[1,0], dtype=np.uint8)[:preamble_len]
              self.syncword = np.array(list(syncword), dtype=np.uint8)
              
              #Make values are binary
              if np.any(self.syncword > 1):
              	print(np.any(self.syncword > 1))
              	raise ValueError("Inavlid Syncword")
              
              # Register port and handler
              self.message_port_register_in(pmt.intern('MSG_In'))
              self.message_port_register_out(pmt.intern('Packet'))
              self.set_msg_handler(pmt.intern('MSG_In'), self.handle_msg)
              
              
          def handle_msg(self, msg):
              #Get msg
              payload = pmt.to_python(msg)
              
              print(f"Syncword Len {len(self.syncword)} syncword: {self.syncword}")
              print(f"Payload: {payload}\n Payload type: {type(payload)}")
              
              payload = np.fromstring(payload[1], dtype=np.uint8)
              payload_len = np.array([len(payload)], dtype=np.uint8)
              print(f"payload_len {payload_len}")
              
              print(f"payload_len + payload: {np.unpackbits(np.concatenate((payload_len, payload)), bitorder='big')}")
              packet = np.concatenate((self.preamble, self.syncword, np.unpackbits(np.concatenate((payload_len, payload)), bitorder='big')))
              print(f"packet: {packet}")
           
              #Create PMT u8vector
              pmt_out = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet), packet))
              self.message_port_pub(pmt.intern('Packet'), pmt_out)
    preamble_len: '11'
    syncword: '"1110010"'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: Payload
    label: Payload
    type: string
    value: '"Hello World!"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    dev_addr: '"serial=30F5982"'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_2, MSG_In]
- [epy_block_2, Packet, blocks_message_debug_0, print]
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_0, set_msg]

metadata:
  file_format: 1
  grc_version: 3.10.7.0

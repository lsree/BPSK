options:
  parameters:
    generate_options: qt_gui
    id: USRP_TX
    output_language: python
    title: USRP TX
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    label: Carrier Frequency
    start: 905e6
    step: 1e4
    stop: 930e6
    value: 915e6
  states: {}
- name: cos_freq
  id: variable_qtgui_range
  parameters:
    label: Carrier Frequency
    start: 500e3
    step: 1e4
    stop: 8e6
    value: 1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/sps
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rf/Documents/BPSK/byte_tx
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rf/Documents/BPSK/byte_tx
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2000'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: '"tx_pkt_len"'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='PDU to Burst',   # will show up in GRC\n            in_sig=None,\n            out_sig=[np.uint8]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        \n        self.queue = []\n        \n        # Register port and handler\n        self.message_port_register_in(pmt.intern('PDU'))\n        self.set_msg_handler(pmt.intern('PDU'), self.handle_msg)\n        \n    def handle_msg(self, msg):\n        msg = pmt.to_python(msg)\n        print(msg[1])\n        self.queue.append(msg[1])\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        #output_items[0][:] = input_items[0] * self.example_param\n        return len(output_items[0])\n        \n  \n"
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, symbol_map=[-1+0j, 1+0j]):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PSK Mod',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.symbol_map = np.array(symbol_map)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = self.symbol_map[input_items[0]]
              return len(output_items[0])
    symbol_map: '[-1+0j, 1+0j]'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import queue


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble_len=12, syncword="1110010"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Packetize',   # will show up in GRC
                  in_sig= None,
                  out_sig= None
              )
              
              #Store Variables
              self.preamble = np.array(int((preamble_len+1)/2)*[1,0], dtype=np.uint8)[:preamble_len]
              self.syncword = np.array(list(syncword), dtype=np.uint8)
              
              #Make values are binary
              if np.any(self.syncword > 1):
              	print(np.any(self.syncword > 1))
              	raise ValueError("Inavlid Syncword")
              
              # Register port and handler
              self.message_port_register_in(pmt.intern('MSG_In'))
              self.message_port_register_out(pmt.intern('Unpacked Packet'))
              self.set_msg_handler(pmt.intern('MSG_In'), self.handle_msg)
              
              
          def handle_msg(self, msg):
              #Get msg
              payload = pmt.to_python(msg)
              
              payload = np.fromstring(payload[1], dtype=np.uint8)
              payload_len = np.array([len(payload)], dtype=np.uint8)
              
              packet = np.concatenate((self.preamble, self.syncword, np.unpackbits(np.concatenate((payload_len, payload)), bitorder='big')))

           
              #Create PMT u8vector
              pmt_out = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet), packet))
              self.message_port_pub(pmt.intern('Unpacked Packet'), pmt_out)
    preamble_len: '11'
    syncword: '"1110010"'
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '256'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"tx_pkt_len"'
    type: byte
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: Payload
    label: Payload
    type: string
    value: '"Hello World!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.51'
    decim: '1'
    gain: '.5'
    ntaps: 32*sps-1
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    dev_addr: '"serial=30F5982"'
    gain0: gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: carrier_freq
    dev_addr: '"serial=30F5982"'
    gain0: gain
    len_tag_name: '"tx_pkt_len"'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_sink_x_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_2, MSG_In]
- [blocks_repeat_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tag_debug_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', blocks_repeat_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_1, '0', root_raised_cosine_filter_0, '0']
- [epy_block_2, Unpacked Packet, epy_block_0, PDU]
- [epy_block_2, Unpacked Packet, pdu_pdu_to_stream_x_0, pdus]
- [epy_block_2, Unpacked Packet, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_0, set_msg]
- [root_raised_cosine_filter_0, '0', blocks_file_sink_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', uhd_usrp_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

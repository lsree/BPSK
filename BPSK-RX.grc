options:
  parameters:
    generate_options: qt_gui
    id: BPSK_RX
    output_language: python
    title: BPSK Recieve
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: Baseband gain
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '8'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 85e6
    step: 1e5
    stop: 110e7
    value: 89.7e6
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 2.3e9
    step: 1e5
    stop: 2.5e9
    value: 2.4e9
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: LNA Gain
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '12'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '11'
    stop: '11'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: RTL_BPSK_RX
    type: complex
    unbuffered: 'True'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: bb_gain
    bw0: samp_rate
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX Waterfall"'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: sps
    type: fir_filter_ccf
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: '"rtl=0"'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_file_sink_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', root_raised_cosine_filter_0, '0']

metadata:
  file_format: 1
